<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vector Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00044.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="94553230-BF86-4759-9235-6AA3A69C07EC">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="E0E82191-4538-4316-ABBB-90DDB274B67C">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A97558CA-142F-4FB4-A196-384368B88620">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="74F6A98B-F778-4C0D-ADDE-4A70E48B9F5B">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A1D62DA6-95C0-44AA-8866-42E97DB473D9">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="000ADCC8-7D01-4803-9E14-B3FB67D753A7">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="C2628C6F-9690-4F40-9C8A-2076557AD80E">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="3FDABC43-0F2B-45FE-89FE-AEF799B97B61">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="14BCA7AB-3651-4A58-BF1A-250A70E735F0">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="7BB85E08-5113-40F9-99FB-5C6CC6506E86">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="01814591-ABB4-4234-9DE4-922A19EAEAEC">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="3D91BD44-0DAF-43E0-BAFD-0D095AB1603D">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="42E8802F-4A91-4218-BBFB-BA1D994FD486">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0813F771-504C-48F6-BA0F-D34DBDCE0C70">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1B0437B6-AF7B-428F-928D-B3262035116F">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="53D82F5B-432D-4DD4-B924-1DBB415C2F72">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="819969E8-8F7D-4C5D-9F67-D0011305C793">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="1DBDB25E-4EB9-40DB-A264-BA89324B4029">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="9ED98566-3F07-4E90-9F42-775669E5D0FA">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="5B443A7A-A475-499F-91A6-26A6E1988DF6">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="99819697-B0B7-4874-84B6-7C25F369E730">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D7457558-05F2-4FC3-ABB4-C0633E610192">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="63FAF86C-7770-4EED-902A-F6F1D7AF646B">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="AFB9F090-7931-435F-B0A4-1760A087E154">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0FDAB23C-5127-4BAD-A726-E918C863F92A">
      <SHORT-NAME>SwAddrMethods</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="98EFF549-83D2-4D11-8470-48946422D731">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="108D1DA2-1A44-4FCB-B59A-84B640712389">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="87ECB115-9DC9-401A-BCD3-2EC34C0C5F9A">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="DC285E03-1E75-4D1D-AE2D-AA0A3BBFD434">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C3F94050-A510-4409-AE86-3DDAE87E2DD2">
      <SHORT-NAME>VehicleProject</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="438710CC-0A67-4879-A3F4-DFE0183A10DA">
      <SHORT-NAME>Diagnostics</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="71D4FCFD-7A0E-45C1-8764-E0D7915F1EB5">
      <SHORT-NAME>NM</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C3797872-7486-4D1E-B9C1-A1325D206258">
      <SHORT-NAME>TP</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="5D9A9ADD-3B0D-4C6A-953E-5FE5886118DB">
      <SHORT-NAME>Cluster</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C10AB2F7-BD67-49C3-8FFE-317F53AE543F">
      <SHORT-NAME>ECU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="91825790-BC45-4789-9BD0-696BFBC88A26">
      <SHORT-NAME>Gateway</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="037AE7CE-A893-4FE8-A5E5-8C0DA41044DA">
      <SHORT-NAME>IPDUGroup</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0D9EBB51-2148-4AE9-AA52-94D7BD5BF902">
      <SHORT-NAME>CanFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C11E93AB-1C17-4B45-BD1E-E0868DC27F7C">
      <SHORT-NAME>LinFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="90ED5693-BC11-407E-9130-713AA86486A9">
      <SHORT-NAME>FlexrayFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="753826BC-BD3B-48D1-AC6E-A0BB2ABDF14D">
      <SHORT-NAME>PDU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="18EE3105-1CBC-4C2B-AB80-B7147E258C1E">
      <SHORT-NAME>ISignal</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6C676AD0-45F4-4C56-916F-4A2BF1A7AFC5">
      <SHORT-NAME>DataType</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="1872DA4A-C133-4011-A82F-F4C616C7E92F">
          <SHORT-NAME>Constraint</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A3A63F3C-7C4E-4978-B0E0-2E2194F0E478">
      <SHORT-NAME>Constant</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="F5C0D974-4691-4F02-9714-6292412CA0C1">
      <SHORT-NAME>Signal</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>