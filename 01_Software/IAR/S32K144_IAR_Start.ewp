# IAR project S32K144_IAR_Start.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __ICCARM__; CPU_S32K148; BRS_DERIVATIVE_S32K144; BASIC_RUNTIME_SYSTEM_TYPE_MSR4; DISABLE_WDOG
  ICCARM.CCIncludePath2: ..\BSW\BswM; ..\BSW\Can; ..\BSW\CanIf; ..\BSW\CanSM; ..\BSW\CanTrcv_30_Tja1043; ..\BSW\Com; ..\BSW\ComM; ..\BSW\Crc; ..\BSW\Det; ..\BSW\Ea; ..\BSW\EcuM; ..\BSW\Eep_30_XXi2c01; ..\BSW\IoHwAb; ..\BSW\Mcal_S32k; ..\BSW\MemIf; ..\BSW\Nm; ..\BSW\NmOsek; ..\BSW\NvM; ..\BSW\Os; ..\BSW\PduR; ..\BSW\RamTst; ..\BSW\vDem42; ..\BSW\VStdLib; ..\BSW\WdgIf; ..\BSW\WdgM; ..\MCAL\Adc_TS_T40D2M10I1R0\include; ..\MCAL\Base_TS_T40D2M10I1R0\include; ..\MCAL\Dio_TS_T40D2M10I1R0\include; ..\MCAL\Fls_TS_T40D2M10I1R0\include; ..\MCAL\Gpt_TS_T40D2M10I1R0\include; ..\MCAL\Icu_TS_T40D2M10I1R0\include; ..\MCAL\Mcu_TS_T40D2M10I1R0\include; ..\MCAL\Ocu_TS_T40D2M10I1R0\include; ..\MCAL\Port_TS_T40D2M10I1R0\include; ..\MCAL\Spi_TS_T40D2M10I1R0\include; ..\MCAL\Wdg_TS_T40D2M10I1R0\include; ..\Appl\GenData; ..\Appl\GenData\include; ..\Appl\GenData\Components; ..\Appl\Include; ..\Appl\shared\zBrs_AsrEmbeddedRunTimeSystemCfg5; ..\Appl\shared\zBrs_ArmCommon; ..\Appl\shared\zBrs_S32Arm; ..\Device; ..\MCAL\Dio_TS_T40D2M10I1R0\include; ..\Appl\Source\Ct_LEDCtrl; ..\BSW\_Common; ..\Appl\GenData
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: S32K144_IAR_Start.srec
  ILINK.IlinkOutputFile: S32K144_IAR_Start.elf
  ILINK.IlinkIcfFile: D:\NXP_S32K144_AutoSAR_Development\NXP_S32K144_AutoSAR_Development\01_Software\Appl\S32K148Asr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Appl
    ../Appl/: BrsAsrMain.c S32K148Asr_new.icf
  group Appl/GenData
    ../Appl/GenData/: BswM_Lcfg.c BswM_PBcfg.c Can_Lcfg.c Can_PBcfg.c CanIf_Lcfg.c CanIf_PBcfg.c CanSM_Lcfg.c Com_Lcfg.c Com_PBcfg.c ComM_Lcfg.c ComM_PBcfg.c Det_Cfg.c EcuM_Cfg.c EcuM_Init_Cfg.c EcuM_Init_PBcfg.c EcuM_PBcfg.c Os_AccessCheck_Lcfg.c Os_Alarm_Lcfg.c Os_Application_Lcfg.c Os_Barrier_Lcfg.c Os_Core_Lcfg.c Os_Counter_Lcfg.c Os_Error_Lcfg.c Os_Hal_Context_Lcfg.c Os_Hal_Core_Lcfg.c Os_Hal_Entry_Lcfg.c Os_Hal_EntryAsm_Lcfg.asm Os_Hal_Interrupt_Lcfg.c Os_Hal_Kernel_Lcfg.c Os_Hal_MemoryProtection_Lcfg.c Os_Hal_Timer_Lcfg.c Os_Hook_Lcfg.c Os_Ioc_Lcfg.c Os_Isr_Lcfg.c Os_MemoryProtection_Lcfg.c Os_Peripheral_Lcfg.c Os_Resource_Lcfg.c Os_Scheduler_Lcfg.c Os_ScheduleTable_Lcfg.c Os_ServiceFunction_Lcfg.c Os_Spinlock_Lcfg.c Os_Stack_Lcfg.c Os_Task_Lcfg.c Os_TimingProtection_Lcfg.c Os_Trace_Lcfg.c Os_XSignal_Lcfg.c PduR_Lcfg.c PduR_PBcfg.c Rte.c
  group Appl/GenData/src
    ../Appl/GenData/src/: Dio_Cfg.c Mcu_Cfg.c Mcu_PBcfg.c Port_Cfg.c Port_PBcfg.c
  group Appl/Source
    ../Appl/Source/: BswM_Callout_Stubs.c Ct_LEDCtrl.c CtLedTask.c EcuM_Callout_Stubs.c IPDU_Callout.c Os_Callout_Stubs.c OsAppTask.c
  group BSW/BswM
    ../BSW/BswM/: BswM.c
    ../BSW/CanTp/: CanTp.h CanTp_Cbk.h CanTp_Priv.h CanTp_Types.h
  group BSW/CAN
    ../BSW/Can/: Can.c Can_Irq.c
  group BSW/CANIF
    ../BSW/CanIf/: CanIf.c
  group BSW/CANSM
    ../BSW/CanSM/: CanSM.c
  group BSW/CanTrcv_TJA1043
    ../BSW/CanTrcv_30_Tja1043/: CanTrcv_30_Tja1043.c
  group BSW/COM
    ../BSW/Com/: Com.c
  group BSW/ComM
    ../BSW/ComM/: ComM.c
  group BSW/Det
    ../BSW/Det/: Det.c
  group BSW/EcuM
    ../BSW/EcuM/: EcuM.c
  group BSW/Os
    ../BSW/Os/: Os_AccessCheck.c Os_Alarm.c Os_Application.c Os_Barrier.c Os_Bit.c Os_BitArray.c Os_Core.c Os_Counter.c Os_Deque.c Os_Error.c Os_Event.c Os_Fifo.c Os_Fifo08.c Os_Fifo16.c Os_Fifo32.c Os_FifoRef.c Os_Hal_Compiler_Arm.c Os_Hal_Compiler_Iar.c Os_Hal_Compiler_TiInt.asm Os_Hal_Context_v7m.c Os_Hal_ContextAsm.asm Os_Hal_Core.c Os_Hal_Entry.c Os_Hook.c Os_Interrupt.c Os_Ioc.c Os_Isr.c Os_Job.c Os_Lock.c Os_MemoryProtection.c Os_Peripheral.c Os_PriorityQueue.c Os_Resource.c Os_Scheduler.c Os_ScheduleTable.c Os_ServiceFunction.c Os_Spinlock.c Os_Stack.c Os_Task.c Os_Thread.c Os_Timer.c Os_TimingProtection.c Os_Trace.c Os_Trap.c Os_XSignal.c
  group BSW/PDUR
    ../BSW/PduR/: PduR.c PduR_Bm.c PduR_Fm.c PduR_Lock.c PduR_McQ.c PduR_RmIf.c PduR_RmTp.c PduR_RmTp_TxInst.c PduR_Sm.c
  group BSW/VstdLib
    ../BSW/VStdLib/: vstdlib.c
  group Device
    ../Device/: startup.c startup_S32K148.s system_S32K148.c
  group MCAL/DIO
    ../MCAL/Dio_TS_T40D2M10I1R0/src/: Dio.c Dio_Gpio.c
  group MCAL/MCU
    ../MCAL/Mcu_TS_T40D2M10I1R0/src/: Mcu.c Mcu_CMU.c Mcu_CMU_Irq.c Mcu_CortexM4.c Mcu_IPW.c Mcu_IPW_Irq.c Mcu_PCC.c Mcu_PMC.c Mcu_PMC_Irq.c Mcu_RCM.c Mcu_SCG.c Mcu_SIM.c Mcu_SMC.c
  group MCAL/PORT
    ../MCAL/Port_TS_T40D2M10I1R0/src/: Port.c Port_Ipw.c Port_Port_Ci.c
